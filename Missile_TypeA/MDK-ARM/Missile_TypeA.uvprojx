# Keil uVision project Missile_TypeA.uvprojx, settings and files
target Missile_TypeA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Missile_TypeA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xxUSE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./User;../FATFS;..\application;..\application\output;..\application\protocol;..\bsp;..\module\bmi088\arm_math\Include;..\module\bmi088\arm_math;..\module\bmi088;..\module\can_comm;..\module\controller\stm32;..\module\controller;..\module\crc8_crc16;..\module\dji_motor;..\module\ist8310;..\module\kalman_filter;..\module\oled;..\module\remote_control;..\module\userlib;..\support;D:\Keil_v5\ARM\ARMCLANG\include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group FATFS
    ../FATFS/: diskio.c ff.c ffunicode.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group applications
    ../application/: detect_task.c INS_task.c led_flow_task.c referee.c referee_usart_task.c shoot_task.c
  group moudule
    ../module/arm_math/: arm_cortexM4lf_math.lib
    ../module/can_comm/: can_comm.c
    ../module/controller/: controller.c pid.c
    ../module/controller/stm32/: stm32.c
    ../module/crc8_crc16/: CRC8_CRC16.c
    ../module/dji_motor/: CAN_receive.c
    ../module/ist8310/: ist8310driver.c ist8310driver_middleware.c
    ../module/kalman_filter/: kalman_filter.c QuaternionEKF.c
    ../module/oled/: OLED.c
    ../module/remote_control/: remote_control.c
    ../module/userlib/: user_lib.c
  group boards
    ../bsp/: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_dwt.c bsp_flash.c bsp_i2c.c bsp_imu_pwm.c bsp_laser.c bsp_led.c bsp_missile_shoot.c bsp_PWM.c bsp_rc.c bsp_rng.c bsp_servo_pwm.c bsp_spi.c bsp_usart.c
  group support
    ../support/: fifo.c mem_mang4.c
software components: CMSIS:CORE 4.3.0
